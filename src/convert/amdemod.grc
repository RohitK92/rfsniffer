<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ksan</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>value</key><value>133e6</value></param>
</block>
<block>
<key>blocks_complex_to_interleaved_short</key>
<param><key>id</key><value>blocks_complex_to_interleaved_short_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>vector_output</key><value>False</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0_0_0_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0_0_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0_0_0_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0_0_0_1_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_0_0_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_1_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0_2</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_1_0</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>136975_vdl2.iq</value></param>
<param><key>type</key><value>short</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>decompress.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>32768</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>131550.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>135100.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>129250.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>130250.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>129500.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>131725.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0_0_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>129775.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0_0_0_0_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>128600.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0_0_0_1</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>131975.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0_0_0_1_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>131450.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0_0_0_1_1</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>131200.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0_1</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>130450.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_0_0_1_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>130325.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_1</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>137700.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_1_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>136500.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_0_2</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>134800.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_1</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>136650.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>blocks_wavfile_sink</key>
<param><key>id</key><value>blocks_wavfile_sink_0_1_0</value></param>
<param><key>bits_per_sample</key><value>16</value></param>
<param><key>file</key><value>135200.wav</value></param>
<param><key>samp_rate</key><value>int(12.5e3)</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0_0_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0_0_0_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0_0_0_0_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0_0_0_1</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0_0_0_1_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0_0_0_1_1</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0_1</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_0_0_1_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_1</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_1_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_0_2</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_1</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>dc_blocker_xx</key>
<param><key>id</key><value>dc_blocker_xx_0_1_0</value></param>
<param><key>length</key><value>32</value></param>
<param><key>long_form</key><value>True</value></param>
<param><key>type</key><value>ff</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0</value></param>
<param><key>center_freq</key><value>131.550e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0</value></param>
<param><key>center_freq</key><value>135.100e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0</value></param>
<param><key>center_freq</key><value>129.250e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0</value></param>
<param><key>center_freq</key><value>130.025e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0</value></param>
<param><key>center_freq</key><value>-129.5e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0_0</value></param>
<param><key>center_freq</key><value>131.725e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0</value></param>
<param><key>center_freq</key><value>129.775e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0_0</value></param>
<param><key>center_freq</key><value>128.600e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_1</value></param>
<param><key>center_freq</key><value>131.975e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_1_0</value></param>
<param><key>center_freq</key><value>131.450e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_1_1</value></param>
<param><key>center_freq</key><value>131.200e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_1</value></param>
<param><key>center_freq</key><value>130.450e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_0_0_1_0</value></param>
<param><key>center_freq</key><value>130.325e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_1</value></param>
<param><key>center_freq</key><value>137.700e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_1_0</value></param>
<param><key>center_freq</key><value>136.500e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_0_2</value></param>
<param><key>center_freq</key><value>134.800e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_1</value></param>
<param><key>center_freq</key><value>136.975e6-center_freq</value></param>
<param><key>decim</key><value>10</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.complex_band_pass(1,10e6,-1e6/(2*10),1e6/(2*10), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_2</value></param>
<param><key>center_freq</key><value>136.650e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>freq_xlating_fir_filter_xxx_0_2_0</value></param>
<param><key>center_freq</key><value>135.200e6-center_freq</value></param>
<param><key>decim</key><value>800</value></param>
<param><key>samp_rate</key><value>10e6</value></param>
<param><key>taps</key><value>firdes.low_pass(1,10e6,10e6/(2*800), 1000)</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>rational_resampler_xxx</key>
<param><key>id</key><value>rational_resampler_xxx_0</value></param>
<param><key>decim</key><value>100</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>interp</key><value>105</value></param>
<param><key>taps</key><value></value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<connection><source_block_id>blocks_complex_to_interleaved_short_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>dc_blocker_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0_0_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0_0_0_1</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0_0_0_1_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0_0_0_1_1</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0_1</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_0_0_1_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_1</source_block_id><sink_block_id>dc_blocker_xx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_1_0</source_block_id><sink_block_id>dc_blocker_xx_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0_2</source_block_id><sink_block_id>dc_blocker_xx_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_1</source_block_id><sink_block_id>dc_blocker_xx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_1_0</source_block_id><sink_block_id>dc_blocker_xx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>freq_xlating_fir_filter_xxx_0_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_complex_to_interleaved_short_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0</source_block_id><sink_block_id>blocks_wavfile_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0_0_0_1_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0_0_0_1_1</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0_1</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_0_0_1_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_1</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_1_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_0_2</source_block_id><sink_block_id>blocks_wavfile_sink_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_1</source_block_id><sink_block_id>blocks_wavfile_sink_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dc_blocker_xx_0_1_0</source_block_id><sink_block_id>blocks_wavfile_sink_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_1_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_0_0_1_1</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0_0_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_0_0_1_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_1</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_1_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_0_2</source_block_id><sink_block_id>blocks_complex_to_mag_0_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_1</source_block_id><sink_block_id>rational_resampler_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_2</source_block_id><sink_block_id>blocks_complex_to_mag_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>freq_xlating_fir_filter_xxx_0_2_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rational_resampler_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
