<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>compress_fft</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>run_options</key><value>run</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>N</value></param>
<param><key>label</key><value>N</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>400</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>file</key><value>/tmp/compress_fft.iq</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>file</key><value>/tmp/capture.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>False</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>N</value></param>
</block>
<block>
<key>fft_vxx</key>
<param><key>id</key><value>fft_vxx_0</value></param>
<param><key>fft_size</key><value>N</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>shift</key><value>True</value></param>
<param><key>window</key><value>window.hanning(N)</value></param>
</block>
<block>
<key>rfsniffer_stream_to_vector_overlap</key>
<param><key>id</key><value>rfsniffer_stream_to_vector_overlap_0</value></param>
<param><key>nitems_per_block</key><value>N</value></param>
<param><key>overlap</key><value>N/2</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>rfsniffer_stream_to_vector_overlap_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>rfsniffer_stream_to_vector_overlap_0</source_block_id><sink_block_id>fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
